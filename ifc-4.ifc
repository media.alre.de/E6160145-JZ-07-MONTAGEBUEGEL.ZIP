Properties of the parts of a building model (IFC4)

# File
Description: Montage-Bügel, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: E6160145, Montage-Bügel
In: Raum
Description: Montage-Bügel für Frostschutzthermostat JTF; Classification: EC011349 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: E6160145; ModelLabel: JZ-07; GlobalTradeItemNumber: 4050528031624; ProductURL: https://alre.de/produkt_E6160145
Pset_Specification - NominalLength: 0.138 m; NominalWidth: 0.032 m; NominalDepth: 0.007 m; NetWeight: 0.069
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: Montagebügel; Zubehör: yes; ETIM-Klasse: EC011349; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-E6160145.pdf
